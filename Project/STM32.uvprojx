# Keil uVision project STM32.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,STM32F1_SGA_ENABLE
  c include: ..\Apply\Logic\Inc;..\Apply\Task\Inc;..\Bsp\Bsp\Inc;..\Bsp\OCD\Inc;..\Bsp\FatFs\Inc;..\Bsp\Third\SGA\inc;..\Driver\Inc;..\Hardware\STM32F1XX\CMSIS\Include;..\Hardware\STM32F1XX\CMSIS\Device\ST\STM32F1xx\Include;..\Hardware\STM32F1XX\STM32F1xx_HAL_Driver\Inc;..\Hardware\STM32F1XX\STM32F1xx_HAL_Driver\Inc\Legacy;..\Bsp\Third\RT-Thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Apply/Logic
    ../Apply/Logic/Src/: main.c usercode.c
  group Apply/Task
    ../Apply/Task/Src/: task_irq.c task_sysinit.c task_userinit.c task_uart.c task_adcollect.c
  group Bsp/Bsp
    ../Bsp/Bsp/Src/: bsp_io.c
  group Bsp/OCD
    ../Bsp/OCD/Src/: ocd_ch438q.c ocd_ads1256.c ocd_ads4111.c ocd_at24cxx.c ocd_ds3231.c ocd_fatfs.c ocd_jy901.c ocd_sdcard.c ocd_ad24bit.lib
  group Bsp/FatFs
    ../Bsp/FatFs/Src/: ff.c diskio.c
  group Bsp/SGA
    ../Bsp/Third/SGA/src/: sga_func.c
  group Driver
    ../Driver/Src/: drv_hal.c drv_hal_adc.c drv_hal_delay.c drv_hal_gpio.c drv_hal_iic_soft.c drv_hal_pwm.c drv_hal_spi.c drv_hal_timer.c drv_hal_uart.c
  group Hardware
    ../Hardware/STM32F1XX/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
    ../Hardware/STM32F1XX/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Hardware/STM32F1XX/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Doc
    ../Doc/: 工程目录介绍.txt 工程维护记录.txt 句柄资源示例.txt
